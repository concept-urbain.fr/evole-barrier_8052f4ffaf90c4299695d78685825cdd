Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Evéole Barrière.IFC
Time: 2020-07-01T13:35:08
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: EVEO-BAR-005_Default
In: Default Storey
Material: PE haute densité

# IfcBeam: EVEO-BAR-006_Default
In: Default Storey
Material: PE haute densité

# IfcBeam: EVEO-BAR-007_Default
In: Default Storey
Material: AISI 304

# IfcBeam: EVEO-BAR-010_Default (2)
In: Default Storey
Material: AISI 304

# IfcBuildingElementProxy: EVEO-BAR-003_Default (2)
In: Default Storey
Material: FGS 400-15
Name
EVEO-BAR-003_Default | PSet_Mass_Property - Mass Measure: 31.0216; Area Measure: 1.13219; Volume Measure: 0.00429995
EVEO-BAR-003_Default

# IfcBuildingElementProxy: EVEO-BAR-005_Default (3)
In: Default Storey
Material: PE haute densité

# IfcBuildingElementProxy: EVEO-BAR-006_Default (3)
In: Default Storey
Material: PE haute densité

# IfcBuildingElementProxy: SKIFFY 036 0012 114 11_Default (3)
In: Default Storey
Material: PP copolymère
